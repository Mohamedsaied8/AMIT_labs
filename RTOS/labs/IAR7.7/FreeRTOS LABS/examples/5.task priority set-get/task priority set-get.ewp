# IAR project task priority set-get.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\FreeRTOS\inc; ..\..\FreeRTOS\config; ..\..\FreeRTOS\portable\ARM_CM4F; ..\..\Mcal; $PROJ_DIR$; ..\..\drivers\uart\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: C:\Users\Ramy Elfouly\Desktop\embedded diploma materials\new materials\RTOS\labs\IAR7.5\FreeRTOS LABS\FreeRTOS\config
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app/inc
    ./: print_task.h
  group app/src
    ./: main.c print_task.c
  group Drivers/inc
    ../../drivers/uart/inc/: uart.h
  group Drivers/src
    ../../drivers/uart/src/: uart.c
  group RTOS/config
    ../../FreeRTOS/config/: FreeRTOSConfig.h
  group RTOS/inc
    ../../FreeRTOS/inc/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group RTOS/portable/CM4F
    ../../FreeRTOS/portable/ARM_CM4F/: port.c portasm.s portmacro.h
  group RTOS/portable/MemMang
    ../../FreeRTOS/portable/MemMang/: heap_2.c
  group RTOS/src
    ../../FreeRTOS/src/: list.c queue.c tasks.c
  group Target/MCAL
    ../../Mcal/: TM4C123GH6PM.h
  group Target/startup
    ../../target/: startup_tm4c.c
